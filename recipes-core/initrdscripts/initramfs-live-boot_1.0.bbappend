#
# Add an updated live boot script, which supports modern OverlayFS.
#
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
