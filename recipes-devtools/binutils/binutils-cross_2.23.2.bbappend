#
# Enable the x86_64-pep target, which is used for buidling EFI images. 
#
EXTRA_OECONF += "--enable-targets=x86_64-pep"
