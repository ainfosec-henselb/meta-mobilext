#
# Unblacklist GDM, as polkit-gnome is fixed in our layer.
#

PNBLACKLIST[gdm] = ""
